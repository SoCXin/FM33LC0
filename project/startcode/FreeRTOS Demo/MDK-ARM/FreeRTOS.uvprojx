# Keil uVision project FreeRTOS.uvprojx, settings and files
target Example (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: FM33LC04X FMSH
  pack: Keil.FM33LC0XX_DFP.0.1.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ADC_Poll +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: FM33LC0XX,USE_FULL_ASSERTx,__DEBUG,DEBUG_PRINT
  c include: ..\Drivers\CMSIS\Inculde;..\Drivers\FM33LC0xx_FL_Driver\Inc;..\Drivers\CMSIS\Device\FM\FM33xx\Include;..\MF-config\Inc;..\Inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM0
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/arm/: startup_fm33lc0xx.s
  group Application/MF-Config
    ../MF-config/Src/: mf_config.c
    ../Src/: adc.c bstim32_timing.c lptim32_timing.c uart.c taskuart.c gpio.c taskadc.c
  group Application/User
    ../Src/: main.c user_init.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33lc0xx.c
  group Drivers/FM33LC0xx_LL_Driver
    ../Drivers/FM33LC0xx_FL_Driver/Src/: fm33lc0xx_fl_adc.c fm33lc0xx_fl_aes.c fm33lc0xx_fl_atim.c fm33lc0xx_fl_bstim32.c fm33lc0xx_fl_comp.c fm33lc0xx_fl_crc.c fm33lc0xx_fl_dma.c fm33lc0xx_fl_flash.c fm33lc0xx_fl_gpio.c fm33lc0xx_fl_gptim.c fm33lc0xx_fl_divas.c fm33lc0xx_fl_i2c.c fm33lc0xx_fl_iwdt.c fm33lc0xx_fl_lptim32.c fm33lc0xx_fl_lpuart.c fm33lc0xx_fl_opa.c fm33lc0xx_fl_pmu.c fm33lc0xx_fl_rcc.c fm33lc0xx_fl_rng.c fm33lc0xx_fl_rtc.c fm33lc0xx_fl_spi.c fm33lc0xx_fl_svd.c fm33lc0xx_fl_u7816.c fm33lc0xx_fl_uart.c fm33lc0xx_fl_wwdt.c
  group FreeRTOS/Source
    ../FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Port
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM0/: port.c
