# Keil uVision project demo.uvprojx, settings and files
target qitas (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo +hex
  AfterMake: fromelf.exe --bin -o./demo.bin ./obj/demo.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\USER;.\USER\SysTick;..\libs\CMSIS\CM3\CoreSupport;..\libs\STM32F10x_StdPeriph_Driver\inc;..\libs\STM32F10x_StdPeriph_Driver\src;..\libs\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\libs\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group libs
    ../Libs/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
    ./USER/SysTick/: systick.c stm32f10x_systick.c
  group Startup
    ../Libs/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.h
    ../Libs/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libs/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
software components: CMSIS:CORE 5.0.0
